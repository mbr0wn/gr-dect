<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_channelizer</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>CEL's Angels</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>2nd Input</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.25*samp_rate</value></param>
<param><key>stop</key><value>3*samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ifs</value></param>
<param><key>value</key><value>11 * samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.728e6</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>ifs</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq2</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>ifs</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>ifs</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>[]</value></param>
<param><key>nchans</key><value>11</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>taps</key><value>[0.0006537547825426158,9.313312876354723e-06,-6.299838768950849e-05,-0.00018878930568958334,-0.00037153284876129377,-0.0006136553557844623,-0.0009149562401950792,-0.001272814918398725,-0.0016806952527983132,-0.002128668188470968,-0.002602204413298311,-0.003083297515377746,-0.0035497933391604847,-0.003977719152629958,-0.004341257721598998,-0.004615521678305365,-0.004771124540697786,-0.004788265407458639,-0.004646286296338254,-0.004331452936571693,-0.0038372326506257146,-0.003165106728406669,-0.0023257984599704524,-0.0013396685140809206,-0.00023665125011815036,0.0009440630676040976,0.0021552449290473327,0.003342732802091095,0.004448114238415341,0.005411050328080489,0.006172416961859839,0.006675786400630179,0.006873870646897508,0.006728547074260832,0.0062153580055531715,0.005325906775304877,0.004069504604174098,0.002474692284667149,0.0005896281909764053,-0.0015183964341382822,-0.003764284210578621,-0.006047593605217487,-0.008255414925769889,-0.010266739786556244,-0.01195711402348082,-0.01320367738533109,-0.013890056791186003,-0.013913105926494838,-0.013186754166071346,-0.011647382232074758,-0.0092579136254659,-0.006010614215460377,-0.0019292718691444966,0.0029300988520201726,0.008479850006955425,0.014602588997797152,0.021154544714726692,0.027969705742854803,0.03486554984482907,0.04164949134728282,0.04812543216138635,0.05410101243898551,0.05939535526650658,0.06384526044290267,0.06731178793147705,0.06968581708300174,0.07089203120461536,0.07089203120461536,0.06968581708300174,0.06731178793147705,0.06384526044290267,0.05939535526650658,0.05410101243898551,0.04812543216138635,0.04164949134728282,0.03486554984482907,0.027969705742854803,0.021154544714726692,0.014602588997797152,0.008479850006955425,0.0029300988520201726,-0.0019292718691444966,-0.006010614215460377,-0.0092579136254659,-0.011647382232074758,-0.013186754166071346,-0.013913105926494838,-0.013890056791186003,-0.01320367738533109,-0.01195711402348082,-0.010266739786556244,-0.008255414925769889,-0.006047593605217487,-0.003764284210578621,-0.0015183964341382822,0.0005896281909764053,0.002474692284667149,0.004069504604174098,0.005325906775304877,0.0062153580055531715,0.006728547074260832,0.006873870646897508,0.006675786400630179,0.006172416961859839,0.005411050328080489,0.004448114238415341,0.003342732802091095,0.0021552449290473327,0.0009440630676040976,-0.00023665125011815036,-0.0013396685140809206,-0.0023257984599704524,-0.003165106728406669,-0.0038372326506257146,-0.004331452936571693,-0.004646286296338254,-0.004788265407458639,-0.004771124540697786,-0.004615521678305365,-0.004341257721598998,-0.003977719152629958,-0.0035497933391604847,-0.003083297515377746,-0.002602204413298311,-0.002128668188470968,-0.0016806952527983132,-0.001272814918398725,-0.0009149562401950792,-0.0006136553557844623,-0.00037153284876129377,-0.00018878930568958334,-6.299838768950849e-05,9.313312876354723e-06,0.0006537547825426158]</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
