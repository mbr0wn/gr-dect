<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_channelizer</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>CEL's Angels</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ifs</value></param>
<param><key>value</key><value>11 * samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.728e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/mbr0wn/paging_foo_dect_19.08Msps.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/mbr0wn/idle_foo_dect_19.08Msps.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>ifs</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0</value></param>
<param><key>chan_index</key><value>0</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0</value></param>
<param><key>chan_index</key><value>10</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0_0</value></param>
<param><key>chan_index</key><value>2</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0_0_0</value></param>
<param><key>chan_index</key><value>6</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0_0_0_0</value></param>
<param><key>chan_index</key><value>7</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0_0_0_0_0</value></param>
<param><key>chan_index</key><value>9</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0_0_0_1</value></param>
<param><key>chan_index</key><value>8</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_0_1</value></param>
<param><key>chan_index</key><value>4</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_1</value></param>
<param><key>chan_index</key><value>1</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_1_0</value></param>
<param><key>chan_index</key><value>5</value></param>
</block>
<block>
<key>dect_burst_smartz</key>
<param><key>id</key><value>dect_burst_smartz_0_2</value></param>
<param><key>chan_index</key><value>3</value></param>
</block>
<block>
<key>dect_pipe_sink</key>
<param><key>id</key><value>dect_pipe_sink_0</value></param>
<param><key>fifo</key><value>/tmp/dect-test</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>[6,7,8,9,10,0,1,2,3,4,5]</value></param>
<param><key>nchans</key><value>11</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>taps</key><value>[0.0006537547825426158,9.313312876354723e-06,-6.299838768950849e-05,-0.00018878930568958334,-0.00037153284876129377,-0.0006136553557844623,-0.0009149562401950792,-0.001272814918398725,-0.0016806952527983132,-0.002128668188470968,-0.002602204413298311,-0.003083297515377746,-0.0035497933391604847,-0.003977719152629958,-0.004341257721598998,-0.004615521678305365,-0.004771124540697786,-0.004788265407458639,-0.004646286296338254,-0.004331452936571693,-0.0038372326506257146,-0.003165106728406669,-0.0023257984599704524,-0.0013396685140809206,-0.00023665125011815036,0.0009440630676040976,0.0021552449290473327,0.003342732802091095,0.004448114238415341,0.005411050328080489,0.006172416961859839,0.006675786400630179,0.006873870646897508,0.006728547074260832,0.0062153580055531715,0.005325906775304877,0.004069504604174098,0.002474692284667149,0.0005896281909764053,-0.0015183964341382822,-0.003764284210578621,-0.006047593605217487,-0.008255414925769889,-0.010266739786556244,-0.01195711402348082,-0.01320367738533109,-0.013890056791186003,-0.013913105926494838,-0.013186754166071346,-0.011647382232074758,-0.0092579136254659,-0.006010614215460377,-0.0019292718691444966,0.0029300988520201726,0.008479850006955425,0.014602588997797152,0.021154544714726692,0.027969705742854803,0.03486554984482907,0.04164949134728282,0.04812543216138635,0.05410101243898551,0.05939535526650658,0.06384526044290267,0.06731178793147705,0.06968581708300174,0.07089203120461536,0.07089203120461536,0.06968581708300174,0.06731178793147705,0.06384526044290267,0.05939535526650658,0.05410101243898551,0.04812543216138635,0.04164949134728282,0.03486554984482907,0.027969705742854803,0.021154544714726692,0.014602588997797152,0.008479850006955425,0.0029300988520201726,-0.0019292718691444966,-0.006010614215460377,-0.0092579136254659,-0.011647382232074758,-0.013186754166071346,-0.013913105926494838,-0.013890056791186003,-0.01320367738533109,-0.01195711402348082,-0.010266739786556244,-0.008255414925769889,-0.006047593605217487,-0.003764284210578621,-0.0015183964341382822,0.0005896281909764053,0.002474692284667149,0.004069504604174098,0.005325906775304877,0.0062153580055531715,0.006728547074260832,0.006873870646897508,0.006675786400630179,0.006172416961859839,0.005411050328080489,0.004448114238415341,0.003342732802091095,0.0021552449290473327,0.0009440630676040976,-0.00023665125011815036,-0.0013396685140809206,-0.0023257984599704524,-0.003165106728406669,-0.0038372326506257146,-0.004331452936571693,-0.004646286296338254,-0.004788265407458639,-0.004771124540697786,-0.004615521678305365,-0.004341257721598998,-0.003977719152629958,-0.0035497933391604847,-0.003083297515377746,-0.002602204413298311,-0.002128668188470968,-0.0016806952527983132,-0.001272814918398725,-0.0009149562401950792,-0.0006136553557844623,-0.00037153284876129377,-0.00018878930568958334,-6.299838768950849e-05,9.313312876354723e-06,0.0006537547825426158]</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label10</key><value></value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>label6</key><value></value></param>
<param><key>label7</key><value></value></param>
<param><key>label8</key><value></value></param>
<param><key>label9</key><value></value></param>
<param><key>nconnections</key><value>10</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate*11</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>1.897344e9 - 5 * 1.728e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>60</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>ifs</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0_0_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_0_0_1</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_0_1</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_1</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_1_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_1_0</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_2</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dect_burst_smartz_0_2</source_block_id><sink_block_id>dect_pipe_sink_0</sink_block_id><source_key>out</source_key><sink_key>burst</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_null_sink_1_0_0_0_0</sink_block_id><source_key>10</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0</sink_block_id><source_key>10</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_1_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0_0_0_1</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>dect_burst_smartz_0_0_0_0_0_0</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
